Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-11-05T16:42:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 05 16:42:59 2021 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\{CBA5B3BB-AA30-4C38-8D7F-7A9C43291A3A}\ifc * Database version: 5507 * Database creation date: Fri Nov 05 16:42:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 05 16:42:59 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 05 16:42:59 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: City WH 800 1door1drawer(ShadowGray,L,1h)_CVASCV80-SH1G801C0, CVASCV80-SH1G801C0_BIM:City WH 800 1door1drawer(ShadowGray,L,1h)_CVASCV80-SH1G801C0:353573
In: Level 1
Material: White, Chrome, Shadow Gray
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_DistributionFlowElementCommon - Reference: City WH 800 1door1drawer(ShadowGray,L,1h)_CVASCV80-SH1G801C0
